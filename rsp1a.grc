options:
  parameters:
    author: PA0SIM and PE0MJX
    copyright: no, as long as referred to at use
    description: The script gets the IQ data from the rdsplay1a device, resamples it, filters it and demodulate it to USB, 20m band. The result is made availble in two audio sinks for wsprdaemon and for wsjt-x
    generate_options: qt_gui
    id: rsp1a
    output_language: python
    title: WSPRdaemon spot reporter
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '512000'
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:2,0
    samp_rate: samp_rate_audio
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: hw:2,1
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '1800'
    low_cutoff_freq: '1200'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '20'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '5'
    type: float
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '256'
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    num_taps: '256'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    comment: Output to the graph, showing the signal inthe frequency domain
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    fbw: '0.1'
    interp: '3'
    type: ccc
  states: {}
- name: sdrplay3_rsp1a_0
  id: sdrplay3_rsp1a
  parameters:
    AGC: 'False'
    agc_set_point: '-30'
    bandwidth: 200e3
    biasT: 'False'
    center_freq: '7038600'
    dab_notch_filter: 'True'
    dc_offset_mode: 'True'
    debug_mode: 'False'
    freq_corr: '0'
    if_gRdB: '50'
    iq_balance_mode: 'True'
    output_type: fc32
    rf_gR: '20'
    rf_notch_filter: 'True'
    rsp_selector: ''
    sample_rate: samp_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
  states: {state: disabled}
- name: sdrplay3_rsp2_0
  id: sdrplay3_rsp2
  parameters:
    AGC: 'False'
    agc_set_point: '-30'
    antenna: Antenna A
    bandwidth: 200e3
    biasT: 'False'
    center_freq: '14095600'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    if_gRdB: '50'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gR: '30'
    rf_notch_filter: 'False'
    rsp_selector: ''
    sample_rate: '512000'
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_float_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '0', hilbert_fc_0, '0']
- [blocks_complex_to_float_0, '1', hilbert_fc_0_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_imag_0, '0']
- [hilbert_fc_0_0, '0', blocks_complex_to_real_0, '0']
- [rational_resampler_xxx_0, '0', band_pass_filter_0, '0']
- [sdrplay3_rsp1a_0, '0', rational_resampler_xxx_0, '0']
- [sdrplay3_rsp2_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
